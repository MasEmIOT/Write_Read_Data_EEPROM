# Keil uVision project BTL.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c gpio.h gpio.c rcc.h rcc.c uart.h uart.c timer.h timer.c eeprom.h eeprom.c lcd.h i2c.c i2c.h lcd.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
